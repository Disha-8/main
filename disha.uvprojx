# Keil uVision project disha.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: disha
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\Users\DISHA\OneDrive\Documents\disha.c
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: USART_driver.c USART_driver.h GPIO_driver.h GPIO_driver.c SPI_driver.c SPI_driver.h TIMER_Driver.c TIMER_Driver.h encoder_intrupt.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
